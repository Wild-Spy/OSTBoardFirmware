# IAR project samd21_sam_ba.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21E18A Atmel ATSAMD21E18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __ATSAMD21E18A__; SAM_BA_INTERFACE=SAM_BA_BOTH_INTERFACES
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\Atmel\; $TOOLKIT_DIR$\inc\Atmel\samd21; $TOOLKIT_DIR$\CMSIS\Include; ; drivers; utils; utils\preprocessor; utils\interrupt
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __ATSAMD21J18A__; SAM_BA_INTERFACE=SAM_BA_USBCDC_ONLY
  AARM.AUserIncludes: $TOOLKIT_DIR$\inc\Atmel\; $TOOLKIT_DIR$\inc\Atmel\samd21; $TOOLKIT_DIR$\CMSIS\Include; ; drivers; $TOOLKIT_DIR$\inc\Atmel; $TOOLKIT_DIR$\inc\Atmel\samd21
  OBJCOPY.OOCOutputFile: samd21_sam_ba.hex
  ILINK.IlinkOutputFile: samd21_sam_ba.out
  ILINK.IlinkIcfFile: samd21_sam_ba.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ./: main.c sam_ba_monitor.c startup_samd21.c usart_sam_ba.c
  group drivers
    drivers/: cdc_enumerate.c uart_driver.c
  group utils
    utils/: compiler.h interrupt.h status_codes.h
  group utils/interrupt
    utils/interrupt/: interrupt_sam_nvic.c
  group utils/preprocessor
    utils/preprocessor/: mrecursion.h mrepeat.h preprocessor.h stringz.h tpaste.h
